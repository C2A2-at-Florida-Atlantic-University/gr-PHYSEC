options:
  parameters:
    author: Jose Sanchez
    generate_options: no_gui
    id: PSK_RX
    output_language: python
    title: PSK_RX
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: '2'
  states: {}
- name: SDR_ID
  id: variable
  parameters:
    value: '"ip:192.168.2.1"'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: buffer_size
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '2400000000'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: int(32*2)
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: (math.pi*2)/100
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(100e3)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: M
    w: phase_bw
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: nfilts
    osps: '2'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: bandwidth
    bbdc: 'True'
    buffer_size: buffer_size
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''manual'''
    manual_gain1: gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: SDR_ID
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: buffer_size
    port: '40860'
    send_eof: 'False'
    type: complex
  states: {}

connections:
- [digital_costas_loop_cc_0_0, '0', network_udp_sink_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [iio_pluto_source_0, '0', digital_symbol_sync_xx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
