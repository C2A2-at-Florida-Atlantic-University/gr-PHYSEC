options:
  parameters:
    generate_options: qt_gui
    id: rx
    output_language: python
    title: Rx
  states: {}

blocks:
- name: SDR_ID
  id: variable
  parameters:
    value: '"ip:192.168.2.1"'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: buffer_size
  id: variable
  parameters:
    value: 8192*9
  states: {}
- name: freq
  id: variable
  parameters:
    value: '2400000000'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /root/rx_file_sink_0.iq
    type: complex
  states: {state: disabled}
- name: blocks_udp_sink_1
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '40860'
    psize: 8192*9
    type: complex
    vlen: '1'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: bandwidth
    bbdc: 'True'
    buffer_size: buffer_size
    frequency: freq
    gain1: '''manual'''
    manual_gain1: gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    uri: SDR_ID
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: '"RX"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: buffer_size
    srate: samp_rate
    type: complex
  states: {}

connections:
- [iio_pluto_source_0, '0', blocks_udp_sink_1, '0']
- [iio_pluto_source_0, '0', qtgui_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
