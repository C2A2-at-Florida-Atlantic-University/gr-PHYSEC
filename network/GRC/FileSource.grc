options:
  parameters:
    author: Jose Sanchez
    generate_options: no_gui
    id: FileSource
    output_language: python
    title: File Source TX
  states: {}

blocks:
- name: SDR_ID
  id: variable
  parameters:
    value: '"ip:192.168.2.1"'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: buffer_size
  id: variable
  parameters:
    value: '0x800'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '1000000000'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/siwn/siwn-node/network/Matlab/BPSK.dat
    repeat: 'True'
    type: complex
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: gain
    bandwidth: bandwidth
    buffer_size: buffer_size
    cyclic: 'True'
    filter_source: '''Auto'''
    frequency: freq
    samplerate: samp_rate
    type: fc32
    uri: SDR_ID
  states: {}

connections:
- [blocks_file_source_0, '0', iio_pluto_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
