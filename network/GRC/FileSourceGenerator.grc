options:
  parameters:
    author: josea
    generate_options: qt_gui
    id: FileSourceGenerator
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '2400000000'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: 'Channel: Frequency Offset'
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0.025'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: 'Channel: Noise Voltage'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: 'Channel: Timing Offset'
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.0005'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/siwn/siwn-node/network/Matlab/BPSK.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate*2
    type: complex
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    comment: Epsilon is the time offset
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '1'
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: '"Channel Out"'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: '"TX Out"'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate*2
    fc: freq
    fftsize: '1024'
    name: '"RX Out"'
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: TX_Out
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: RX_Out
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: Chan_Out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Chan_Out
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: TX_Out
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: RX_Out
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: TX_Out
  states: {}
- name: virtual_source_2_0_0
  id: virtual_source
  parameters:
    stream_id: Chan_Out
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_0, '0']
- [blocks_throttle2_0_0, '0', virtual_sink_1, '0']
- [channels_channel_model_0_0, '0', virtual_sink_2, '0']
- [virtual_source_0, '0', blocks_throttle2_0_0, '0']
- [virtual_source_1, '0', channels_channel_model_0_0, '0']
- [virtual_source_2, '0', qtgui_sink_x_0_0_0_1, '0']
- [virtual_source_2_0, '0', qtgui_sink_x_0_0_0_0, '0']
- [virtual_source_2_0_0, '0', qtgui_sink_x_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
