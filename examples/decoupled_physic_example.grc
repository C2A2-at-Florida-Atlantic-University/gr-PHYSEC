options:
  parameters:
    author: gr-PHYSEC Decoupled Example
    category: Examples
    comment: Example flowgraph for PHYSEC using decoupled blocks
    description: Demonstrates the decoupled PHYSEC framework
    generate_options: qt_gui
    hier_block_src_path: '.:src:'
    id: decoupled_physic_example
    output_language: python
    title: PHYSEC Decoupled Blocks Example
  states: {}

blocks:
- name: centerFrequency
  id: variable
  parameters:
    comment: Center frequency for SDR (2.4 GHz)
    value: '2400000000'
  states: {}
- name: fftWindow
  id: variable
  parameters:
    comment: FFT window size for spectrogram generation
    value: '512'
  states: {}
- name: modelPath
  id: variable
  parameters:
    comment: Path to the ONNX model for feature extraction
    value: '"/workspace/data/gr-PHYSEC/models/QExtractor.onnx"'
  states: {}
- name: sampleRate
  id: variable
  parameters:
    comment: Sample rate for SDR (1 MHz)
    value: '1000000'
  states: {}
- name: vectorSize
  id: variable
  parameters:
    comment: Vector size for processing (8192 samples)
    value: '8192'
  states: {}
- name: PHYSEC_feature_extraction_block_0
  id: PHYSEC_feature_extraction_block
  parameters:
    comment: Extracts features from spectrograms using ONNX model
    model_path: modelPath
  states: {}
- name: PHYSEC_feature_quantization_block_0
  id: PHYSEC_feature_quantization_block
  parameters:
    comment: Quantizes features to binary values for key generation
    quantization_method: mean_threshold
  states: {}
- name: PHYSEC_parity_generation_block_0
  id: PHYSEC_parity_generation_block
  parameters:
    k: '128'
    key_length: '512'
    n: '255'
  states: {}
- name: PHYSEC_privacy_amplification_block_0
  id: PHYSEC_privacy_amplification_block
  parameters:
    hash_algorithm: sha3_512
  states: {}
- name: PHYSEC_reconciliation_block_0
  id: PHYSEC_reconciliation_block
  parameters:
    k: '128'
    key_length: '512'
    n: '255'
  states: {}
- name: PHYSEC_spectrogram_block_0
  id: PHYSEC_spectrogram_block
  parameters:
    comment: Creates spectrograms from IQ samples using STFT
    fft_window: fftWindow
    vector_size: vectorSize
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: sampleRate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Saves quantized features to file for analysis
    file: /tmp/physic_quantized_features.txt
    type: byte
    vlen: '512'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    comment: Saves quantized features to file for analysis
    file: /tmp/keys.txt
    type: byte
    vlen: '128'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    comment: Collects samples into vectors for processing
    num_items: vectorSize
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: Throttle for testing (can be removed in production)
    samples_per_second: sampleRate
    type: complex
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2400000000'
    samplerate: sampleRate
    type: fc32
    uri: '"ip:192.168.65.254"'
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    comment: ADALM-PLUTO SDR source for IQ samples
    filter_source: '''Auto'''
    frequency: centerFrequency
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: sampleRate
    type: fc32
    uri: '"ip:192.168.65.254"'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sampleRate
    comment: Displays frequency spectrum of IQ samples
    fc: '0'
    fftsize: '1024'
    label1: IQ Spectrum
    name: QT GUI Freq Sink
    type: complex
  states: {}

connections:
- [PHYSEC_feature_extraction_block_0, '0', PHYSEC_feature_quantization_block_0, '0']
- [PHYSEC_feature_quantization_block_0, '0', PHYSEC_parity_generation_block_0, '0']
- [PHYSEC_feature_quantization_block_0, '0', PHYSEC_reconciliation_block_0, '0']
- [PHYSEC_feature_quantization_block_0, '0', blocks_file_sink_0, '0']
- [PHYSEC_parity_generation_block_0, '0', PHYSEC_reconciliation_block_0, '1']
- [PHYSEC_privacy_amplification_block_0, '0', blocks_file_sink_0_0, '0']
- [PHYSEC_reconciliation_block_0, '0', PHYSEC_privacy_amplification_block_0, '0']
- [PHYSEC_spectrogram_block_0, '0', PHYSEC_feature_extraction_block_0, '0']
- [analog_sig_source_x_0, '0', iio_pluto_sink_0, '0']
- [blocks_stream_to_vector_0, '0', PHYSEC_spectrogram_block_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [iio_pluto_source_0, '0', blocks_throttle_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
