options:
  parameters:
    generate_options: qt_gui
    id: example_flow
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: centerFrequency
  id: variable
  parameters:
    value: '2442000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sampleRate
  id: variable
  parameters:
    value: '50000000'
  states: {}
- name: PHYSEC_feature_extraction_block_0
  id: PHYSEC_feature_extraction_block
  parameters:
    model_path: /path/to/model.onnx
  states: {}
- name: PHYSEC_feature_quantization_block_0
  id: PHYSEC_feature_quantization_block
  parameters:
    quantization_method: mean_threshold
  states: {}
- name: PHYSEC_parity_generation_block_0
  id: PHYSEC_parity_generation_block
  parameters:
    k: '128'
    key_length: '512'
    n: '255'
  states: {}
- name: PHYSEC_privacy_amplification_block_0
  id: PHYSEC_privacy_amplification_block
  parameters:
    hash_algorithm: sha3_512
  states: {}
- name: PHYSEC_reconciliation_block_0
  id: PHYSEC_reconciliation_block
  parameters:
    k: '128'
    key_length: '512'
    n: '255'
  states: {}
- name: PHYSEC_spectrogram_block_0
  id: PHYSEC_spectrogram_block
  parameters:
    fft_window: '512'
    vector_size: '8192'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: byte
    vlen: '128'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '8192'
    type: complex
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: centerFrequency
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: sampleRate
    type: fc32
    uri: '"ip:192.168.65.254"'
  states: {}

connections:
- [PHYSEC_feature_extraction_block_0, '0', PHYSEC_feature_quantization_block_0, '0']
- [PHYSEC_feature_quantization_block_0, '0', PHYSEC_parity_generation_block_0, '0']
- [PHYSEC_feature_quantization_block_0, '0', PHYSEC_reconciliation_block_0, '0']
- [PHYSEC_parity_generation_block_0, '0', PHYSEC_reconciliation_block_0, '1']
- [PHYSEC_privacy_amplification_block_0, '0', blocks_file_sink_0, '0']
- [PHYSEC_reconciliation_block_0, '0', PHYSEC_privacy_amplification_block_0, '0']
- [PHYSEC_spectrogram_block_0, '0', PHYSEC_feature_extraction_block_0, '0']
- [blocks_stream_to_vector_0, '0', PHYSEC_spectrogram_block_0, '0']
- [iio_pluto_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
