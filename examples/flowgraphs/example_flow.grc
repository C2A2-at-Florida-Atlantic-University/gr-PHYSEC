options:
  parameters:
    generate_options: qt_gui
    id: example_flow
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: centerFrequency
  id: variable
  parameters:
    value: '2442000000'
  states: {}
- name: sampleRate
  id: variable
  parameters:
    value: '50000000'
  states: {}
- name: PHYSEC_feature_extraction_block_0
  id: PHYSEC_feature_extraction_block
  parameters:
    model_path: /workspace/siwn/gr-PHYSEC/examples/QExtractor.onnx
  states: {state: disabled}
- name: PHYSEC_feature_quantization_block_0
  id: PHYSEC_feature_quantization_block
  parameters:
    quantization_method: mean_threshold
  states: {state: disabled}
- name: PHYSEC_parity_generation_block_0
  id: PHYSEC_parity_generation_block
  parameters:
    k: '128'
    key_length: '512'
    n: '255'
  states: {state: disabled}
- name: PHYSEC_privacy_amplification_block_0
  id: PHYSEC_privacy_amplification_block
  parameters:
    hash_algorithm: sha3_512
  states: {state: disabled}
- name: PHYSEC_reconciliation_block_0
  id: PHYSEC_reconciliation_block
  parameters:
    k: '128'
    key_length: '512'
    n: '255'
  states: {state: disabled}
- name: PHYSEC_spectrogram_block_0
  id: PHYSEC_spectrogram_block
  parameters:
    fft_window: '512'
    vector_size: '8192'
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Probe signal source
    freq: '1000000'
    offset: '0'
    phase: '0'
    samp_rate: sampleRate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Probe signal source
    freq: '1000000'
    offset: '0'
    phase: '0'
    samp_rate: sampleRate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: byte
    vlen: '128'
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
    vlen: '128'
  states: {state: disabled}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: byte
    vlen: '128'
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '8192'
    type: complex
  states: {state: disabled}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    comment: PlutoSDR sink for transmitting probe
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2442000000'
    len_tag_key: packet_len
    samplerate: sampleRate
    type: fc32
    uri: '"ip:192.168.65.254"'
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: centerFrequency
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: sampleRate
    type: fc32
    uri: '"ip:192.168.65.254"'
  states: {state: disabled}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '2000'
    src_zeros: 'False'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: sampleRate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [PHYSEC_feature_extraction_block_0, '0', PHYSEC_feature_quantization_block_0, '0']
- [PHYSEC_feature_quantization_block_0, '0', PHYSEC_parity_generation_block_0, '0']
- [PHYSEC_feature_quantization_block_0, '0', PHYSEC_reconciliation_block_0, '0']
- [PHYSEC_parity_generation_block_0, '0', PHYSEC_reconciliation_block_0, '1']
- [PHYSEC_parity_generation_block_0, '1', blocks_null_sink_0_0_0, '0']
- [PHYSEC_privacy_amplification_block_0, '0', blocks_file_sink_0, '0']
- [PHYSEC_privacy_amplification_block_0, '0', blocks_null_sink_0, '0']
- [PHYSEC_reconciliation_block_0, '0', PHYSEC_privacy_amplification_block_0, '0']
- [PHYSEC_reconciliation_block_0, '1', blocks_null_sink_0_0, '0']
- [PHYSEC_spectrogram_block_0, '0', PHYSEC_feature_extraction_block_0, '0']
- [analog_sig_source_x_0, '0', iio_pluto_sink_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_stream_to_vector_0, '0']
- [analog_sig_source_x_0_0, '0', qtgui_sink_x_0, '0']
- [blocks_stream_to_vector_0, '0', PHYSEC_spectrogram_block_0, '0']
- [iio_pluto_source_0, '0', blocks_stream_to_vector_0, '0']
- [iio_pluto_source_0, '0', qtgui_sink_x_0, '0']
- [network_udp_source_0, '0', blocks_stream_to_vector_0, '0']
- [network_udp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
