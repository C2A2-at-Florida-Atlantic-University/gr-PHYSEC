options:
  parameters:
    author: Alice Node
    category: '[PHYSEC]'
    comment: Alice protocol node with messaging triggers (ZeroMQ) and PlutoSDR
    description: Alice full-node skeleton in YAML GRC format (GR 3.10)
    generate_options: no_gui
    id: alice_node_protocol
    output_language: python
    run: 'False'
    run_command: env PHYSEC_RX_DELAY_MS=300 {python} -u {filename}
    title: Alice Protocol Node - PHYSEC
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    comment: Number of IQ samples to collect
    value: '2400000000'
  states: {}
- name: key_len
  id: variable
  parameters:
    comment: Final key length (bytes)
    value: '128'
  states: {}
- name: monitor_addr
  id: variable
  parameters:
    comment: ZeroMQ address for status out
    value: '"tcp://192.168.0.142:9100"'
  states: {}
- name: monitor_addr
  id: variable
  parameters:
    comment: ZeroMQ address for control out (to peer)
    value: '"tcp://127.0.0.1:9100"'
  states: {state: disabled}
- name: parity_len
  id: variable
  parameters:
    comment: Parity length (bytes)
    value: '127'
  states: {}
- name: parity_pub_addr
  id: variable
  parameters:
    comment: ZeroMQ address for control out (to peer)
    value: '"tcp://127.0.0.1:9200"'
  states: {state: disabled}
- name: parity_pub_addr
  id: variable
  parameters:
    comment: ZeroMQ address for parity PUB
    value: '"tcp://192.168.0.5:9200"'
  states: {}
- name: peer_ctrl_addr
  id: variable
  parameters:
    comment: ZeroMQ address for control in
    value: '"tcp://192.168.0.2:9102"'
  states: {}
- name: peer_ctrl_addr
  id: variable
  parameters:
    comment: ZeroMQ address for control out (to peer)
    value: '"tcp://127.0.0.1:9102"'
  states: {state: disabled}
- name: peer_ctrl_pub_addr
  id: variable
  parameters:
    comment: ZeroMQ address for control out (to peer)
    value: '"tcp://192.168.0.5:9101"'
  states: {}
- name: peer_ctrl_pub_addr
  id: variable
  parameters:
    comment: ZeroMQ address for control out (to peer)
    value: '"tcp://127.0.0.1:9101"'
  states: {state: disabled}
- name: sample_rate
  id: variable
  parameters:
    comment: Sample rate for SDR
    value: '1000000'
  states: {}
- name: sdr_uri
  id: variable
  parameters:
    comment: PlutoSDR URI
    value: '"ip:192.168.2.1"'
  states: {}
- name: vector_size
  id: variable
  parameters:
    comment: Number of IQ samples to collect
    value: '8192'
  states: {}
- name: PHYSEC_feature_extraction_block_0
  id: PHYSEC_feature_extraction_block
  parameters:
    model_path: /workspace/gr-PHYSEC/examples/QExtractor.onnx
  states: {}
- name: PHYSEC_feature_quantization_block_0
  id: PHYSEC_feature_quantization_block
  parameters:
    quantization_method: mean_threshold
  states: {}
- name: PHYSEC_parity_generation_block_0
  id: PHYSEC_parity_generation_block
  parameters:
    k: '128'
    key_length: '512'
    n: '255'
  states: {}
- name: PHYSEC_privacy_amplification_block_0
  id: PHYSEC_privacy_amplification_block
  parameters:
    hash_algorithm: sha3_512
  states: {}
- name: PHYSEC_spectrogram_block_0
  id: PHYSEC_spectrogram_block
  parameters:
    fft_window: '512'
    vector_size: '8192'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.01'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Probe signal source
    freq: '1000000'
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: alice_rx.iq
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: alice_tx.iq
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_key_0
  id: blocks_file_sink
  parameters:
    comment: Store final key (Alice)
    file: /tmp/alice_key.bin
    type: byte
    vlen: '128'
  states: {}
- name: blocks_file_sink_vec
  id: blocks_file_sink
  parameters:
    comment: Dump collected vectors (placeholder)
    file: alice.iq
    type: complex
    vlen: '8192'
  states: {state: disabled}
- name: blocks_message_debug_parity_0
  id: blocks_message_debug
  parameters:
    comment: Parity PDU debug
  states: {}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    comment: Mute/unmute TX based on control
    mute: 'True'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: Add length tag for parity PDUs
    len_tag_key: '"packet_len"'
    packet_len: parity_len
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    comment: Convert stream to vector for processing
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '127'
    type: byte
  states: {}
- name: epy_block_ctrl
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt, os, threading, time

      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self, name='Alice Controller', in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_in(pmt.intern('evt_in'))
              self.message_port_register_out(pmt.intern('tx_mute'))
              self.message_port_register_out(pmt.intern('out'))
              self.message_port_register_out(pmt.intern('peer'))
              self.message_port_register_out(pmt.intern('rx_ctrl'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
              self.set_msg_handler(pmt.intern('evt_in'), self.handle_evt)
              self.message_port_pub(pmt.intern('tx_mute'), pmt.to_pmt(True))
              self.state = 'idle'
          def _start_rx(self):
              self.message_port_pub(pmt.intern('rx_ctrl'), pmt.intern('start'))
          def handle_msg(self, msg):
              val = pmt.symbol_to_string(msg) if pmt.is_symbol(msg) else str(pmt.to_python(msg))
              if val == 'probe_req' and self.state == 'idle':
                  self.message_port_pub(pmt.intern('out'), pmt.intern('alice_accept'))
                  time.sleep(0.001)
                  self.message_port_pub(pmt.intern('rx_ctrl'), pmt.intern('start'))
                  self.state = 'collecting'
              elif val == 'bob_collect_done' and self.state == 'txing':
                  self.message_port_pub(pmt.intern('tx_mute'), pmt.to_pmt(True))
                  self.message_port_pub(pmt.intern('out'), pmt.intern('alice_tx_stop'))
                  self.state = 'processing'
              elif val in ('reconcile_ok','reconcile_fail'):
                  self.message_port_pub(pmt.intern('out'), pmt.intern('alice_'+val))
                  self.state = 'idle'
              else:
                  self.message_port_pub(pmt.intern('out'), pmt.intern('alice_evt_'+val))
          def handle_evt(self, msg):
              val = pmt.symbol_to_string(msg) if pmt.is_symbol(msg) else str(pmt.to_python(msg))
              if val == 'rx_collected' and self.state == 'collecting':
                  # Optional delay before switching to TX to let Bob prepare RX
                  try:
                      rx2tx_delay_ms = float(os.getenv('PHYSEC_RX2TX_DELAY_MS', '10'))
                  except Exception:
                      rx2tx_delay_ms = 10.0
                  if rx2tx_delay_ms > 0:
                      time.sleep(rx2tx_delay_ms / 1000.0)
                  self.message_port_pub(pmt.intern('tx_mute'), pmt.to_pmt(False))
                  self.message_port_pub(pmt.intern('peer'), pmt.intern('alice_tx_start'))
                  self.message_port_pub(pmt.intern('out'), pmt.intern('alice_tx_start'))
                  self.state = 'txing'
    comment: Alice handshake controller
  states: {}
- name: epy_block_push_iq
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np, socket, json, time, threading, os

      class blk(gr.sync_block):
          def __init__(self, vlen=8192, node_name="Alice"):
              gr.sync_block.__init__(self, name='Monitor Push IQ', in_sig=[(np.complex64, int(vlen))], out_sig=None)
              self.vlen = int(vlen)
              self.node_name = node_name
              self.host = os.getenv('MONITOR_HOST', '192.168.0.142')
              self.port = int(os.getenv('MONITOR_PORT', '9999'))
              self.sock = None
              self._lock = threading.Lock()
              self._connect()

          def _connect(self):
              try:
                  s = socket.socket(socket.AF_INET, socket.SOCK_STREAM)
                  s.settimeout(2.0)
                  s.connect((self.host, self.port))
                  s.settimeout(None)
                  self.sock = s
              except Exception:
                  self.sock = None

          def _send(self, payload):
              try:
                  if self.sock is None:
                      self._connect()
                  if self.sock:
                      data = (json.dumps(payload) + "\n").encode('utf-8')
                      with self._lock:
                          self.sock.sendall(data)
              except Exception:
                  self.sock = None

          def work(self, input_items, output_items):
              vecs = input_items[0]
              for v in vecs:
                  try:
                      data_str = repr([complex(x) for x in v.tolist()])
                      payload = {"type": "data_push", "data_type": "iq_samples", "node_name": self.node_name, "data": data_str, "timestamp": time.time()}
                      self._send(payload)
                  except Exception:
                      pass
              return len(vecs)
    comment: Push IQ vectors to monitor
    node_name: '"Alice"'
    vlen: vector_size
  states: {}
- name: epy_block_push_msg
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt, socket, json, time, threading, os

      class blk(gr.basic_block):
          def __init__(self, node_name="Alice", count_run_on="alice_tx_start"):
              gr.basic_block.__init__(self, name='Monitor Push (msg)', in_sig=None, out_sig=None)
              self.node_name = node_name
              self.count_run_on = str(count_run_on) if count_run_on else ""
              self.host = os.getenv('MONITOR_HOST', '192.168.0.142')
              self.port = int(os.getenv('MONITOR_PORT', '9999'))
              self.run_number = 0
              self.sock = None
              self._lock = threading.Lock()
              self._connect()
              self.message_port_register_in(pmt.intern('in'))
              self.set_msg_handler(pmt.intern('in'), self.handle_msg)

          def _connect(self):
              try:
                  s = socket.socket(socket.AF_INET, socket.SOCK_STREAM)
                  s.settimeout(2.0)
                  s.connect((self.host, self.port))
                  s.settimeout(None)
                  self.sock = s
              except Exception:
                  self.sock = None

          def _send(self, payload):
              try:
                  if self.sock is None:
                      self._connect()
                  if self.sock:
                      data = (json.dumps(payload) + "\n").encode('utf-8')
                      with self._lock:
                          self.sock.sendall(data)
              except Exception:
                  self.sock = None

          def handle_msg(self, msg):
              val = pmt.symbol_to_string(msg) if pmt.is_symbol(msg) else str(pmt.to_python(msg))
              if self.count_run_on and val == self.count_run_on:
                  self.run_number += 1
                  self._send({"type": "data_push", "data_type": "run_update", "node_name": self.node_name, "data": {"run_number": self.run_number, "action": "start"}, "timestamp": time.time()})
              self._send({"type": "data_push", "data_type": "protocol_step", "node_name": self.node_name, "data": {"step": val}, "timestamp": time.time()})
    comment: Push protocol steps and run updates to monitor
    count_run_on: '"alice_tx_start"'
    node_name: '"Alice"'
  states: {}
- name: epy_block_push_quant
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np, socket, json, time, threading, os

      class blk(gr.sync_block):
          def __init__(self, vlen=512, node_name="Alice"):
              gr.sync_block.__init__(self, name='Monitor Push Quantized', in_sig=[(np.uint8, int(vlen))], out_sig=None)
              self.vlen = int(vlen)
              self.node_name = node_name
              self.host = os.getenv('MONITOR_HOST', '192.168.0.142')
              self.port = int(os.getenv('MONITOR_PORT', '9999'))
              self.sock = None
              self._lock = threading.Lock()
              self._connect()

          def _connect(self):
              try:
                  s = socket.socket(socket.AF_INET, socket.SOCK_STREAM)
                  s.settimeout(2.0)
                  s.connect((self.host, self.port))
                  s.settimeout(None)
                  self.sock = s
              except Exception:
                  self.sock = None

          def _send(self, payload):
              try:
                  if self.sock is None:
                      self._connect()
                  if self.sock:
                      data = (json.dumps(payload) + "\n").encode('utf-8')
                      with self._lock:
                          self.sock.sendall(data)
              except Exception:
                  self.sock = None

          def work(self, input_items, output_items):
              vecs = input_items[0]
              for v in vecs:
                  try:
                      data_list = [int(x) for x in (v.tolist() if hasattr(v, 'tolist') else list(v))]
                      payload = {"type": "data_push", "data_type": "quantized_bits", "node_name": self.node_name, "data": data_list, "timestamp": time.time()}
                      self._send(payload)
                  except Exception:
                      pass
              return len(vecs)
    comment: Push quantized bit vectors to monitor
    node_name: '"Alice"'
    vlen: '512'
  states: {}
- name: epy_block_push_spec
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np, socket, json, time, threading, os

      class blk(gr.sync_block):
          def __init__(self, node_name="Alice"):
              gr.sync_block.__init__(self, name='Monitor Push Spectrogram', in_sig=[(np.float32, (6324))], out_sig=None)
              self.node_name = node_name
              self.host = os.getenv('MONITOR_HOST', '192.168.0.142')
              self.port = int(os.getenv('MONITOR_PORT', '9999'))
              self.sock = None
              self._lock = threading.Lock()
              self._connect()

          def _connect(self):
              try:
                  s = socket.socket(socket.AF_INET, socket.SOCK_STREAM)
                  s.settimeout(2.0)
                  s.connect((self.host, self.port))
                  s.settimeout(None)
                  self.sock = s
              except Exception:
                  self.sock = None

          def _send(self, payload):
              try:
                  if self.sock is None:
                      self._connect()
                  if self.sock:
                      data = (json.dumps(payload) + "\n").encode('utf-8')
                      with self._lock:
                          self.sock.sendall(data)
              except Exception:
                  self.sock = None

          def work(self, input_items, output_items):
              specs = input_items[0]
              for spec in specs:
                  try:
                      data_list = spec.tolist() if hasattr(spec, 'tolist') else [list(row) for row in spec]
                      payload = {"type": "data_push", "data_type": "spectrogram", "node_name": self.node_name, "data": data_list, "timestamp": time.time()}
                      self._send(payload)
                  except Exception:
                      pass
              return len(specs)
    comment: Push spectrograms to monitor
    node_name: '"Alice"'
  states: {}
- name: epy_block_rx_gate
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np, pmt

      class blk(gr.sync_block):
          def __init__(self, num_items=8192):
              gr.sync_block.__init__(self, name='RX Gate', in_sig=[np.complex64], out_sig=[np.complex64])
              self.num_items = int(num_items); self.enabled = False; self.count = 0
              self.message_port_register_in(pmt.intern('ctrl'))
              self.message_port_register_out(pmt.intern('evt'))
              self.set_msg_handler(pmt.intern('ctrl'), self._on_ctrl)
          def _on_ctrl(self, msg):
              val = pmt.symbol_to_string(msg) if pmt.is_symbol(msg) else str(pmt.to_python(msg))
              if val == 'start': self.enabled = True; self.count = 0
          def work(self, ins, outs):
              if not self.enabled: return 0
              n = min(len(ins[0]), len(outs[0]), self.num_items - self.count)
              outs[0][:n] = ins[0][:n]; self.count += n
              if self.count >= self.num_items:
                  self.enabled = False
                  self.message_port_pub(pmt.intern('evt'), pmt.intern('rx_collected'))
              return n
    comment: Message-gated RX pass-through of N items
    num_items: vector_size
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: '20000000'
    buffer_size: '32768'
    comment: PlutoSDR sink for transmitting probe
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: freq
    samplerate: sample_rate
    type: fc32
    uri: sdr_uri
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    comment: PlutoSDR source for receiving IQ samples
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''manual'''
    len_tag_key: ''
    manual_gain1: '70'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: sample_rate
    type: fc32
    uri: sdr_uri
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '2000'
    send_eof: 'False'
    type: complex
  states: {state: disabled}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '3000'
    src_zeros: 'False'
    type: complex
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: monitor_addr
    bind: 'False'
    comment: Publish status updates to monitor
    timeout: '100'
  states: {}
- name: zeromq_pub_msg_sink_ctrl
  id: zeromq_pub_msg_sink
  parameters:
    address: peer_ctrl_pub_addr
    comment: Publish control messages to peer
    timeout: '100'
  states: {}
- name: zeromq_pub_msg_sink_parity
  id: zeromq_pub_msg_sink
  parameters:
    address: parity_pub_addr
    comment: Publish parity messages to peer
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: peer_ctrl_addr
    comment: Receive control messages from peer/controller
    timeout: '100'
  states: {}

connections:
- [PHYSEC_feature_extraction_block_0, '0', PHYSEC_feature_quantization_block_0, '0']
- [PHYSEC_feature_quantization_block_0, '0', PHYSEC_parity_generation_block_0, '0']
- [PHYSEC_feature_quantization_block_0, '0', epy_block_push_quant, '0']
- [PHYSEC_parity_generation_block_0, '0', blocks_vector_to_stream_0, '0']
- [PHYSEC_parity_generation_block_0, '1', PHYSEC_privacy_amplification_block_0, '0']
- [PHYSEC_privacy_amplification_block_0, '0', blocks_file_sink_key_0, '0']
- [PHYSEC_spectrogram_block_0, '0', PHYSEC_feature_extraction_block_0, '0']
- [PHYSEC_spectrogram_block_0, '0', epy_block_push_spec, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_mute_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_add_xx_0, '0', network_udp_sink_0, '0']
- [blocks_mute_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_mute_xx_0, '0', iio_pluto_sink_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_stream_to_vector_0, '0', PHYSEC_spectrogram_block_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_file_sink_vec, '0']
- [blocks_stream_to_vector_0, '0', epy_block_push_iq, '0']
- [blocks_vector_to_stream_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [epy_block_ctrl, out, blocks_message_debug_parity_0, print]
- [epy_block_ctrl, out, epy_block_push_msg, in]
- [epy_block_ctrl, out, zeromq_pub_msg_sink_0, in]
- [epy_block_ctrl, peer, blocks_message_debug_parity_0, print]
- [epy_block_ctrl, peer, zeromq_pub_msg_sink_ctrl, in]
- [epy_block_ctrl, rx_ctrl, blocks_message_debug_parity_0, print]
- [epy_block_ctrl, rx_ctrl, epy_block_rx_gate, ctrl]
- [epy_block_ctrl, tx_mute, blocks_message_debug_parity_0, print]
- [epy_block_ctrl, tx_mute, blocks_mute_xx_0, set_mute]
- [epy_block_rx_gate, '0', blocks_stream_to_vector_0, '0']
- [epy_block_rx_gate, evt, blocks_message_debug_parity_0, print]
- [epy_block_rx_gate, evt, epy_block_ctrl, evt_in]
- [iio_pluto_source_0, '0', epy_block_rx_gate, '0']
- [network_udp_source_0, '0', blocks_file_sink_0_0, '0']
- [network_udp_source_0, '0', epy_block_rx_gate, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_parity_0, print]
- [pdu_tagged_stream_to_pdu_0, pdus, zeromq_pub_msg_sink_parity, in]
- [zeromq_sub_msg_source_0, out, blocks_message_debug_parity_0, print]
- [zeromq_sub_msg_source_0, out, epy_block_ctrl, msg_in]

metadata:
  file_format: 1
