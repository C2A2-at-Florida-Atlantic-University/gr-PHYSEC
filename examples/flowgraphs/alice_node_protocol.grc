options:
  parameters:
    author: Alice Node
    category: '[PHYSEC]'
    comment: Alice protocol node with messaging triggers (ZeroMQ) and PlutoSDR
    description: Alice full-node skeleton in YAML GRC format (GR 3.10)
    generate_options: no_gui
    id: alice_node_protocol
    output_language: python
    run: 'False'
    title: Alice Protocol Node - PHYSEC
  states: {}

blocks:
- name: key_len
  id: variable
  parameters:
    comment: Final key length (bytes)
    value: '128'
  states: {}
- name: monitor_addr
  id: variable
  parameters:
    comment: ZeroMQ address for status out
    value: '"tcp://127.0.0.1:9100"'
  states: {}
- name: parity_len
  id: variable
  parameters:
    comment: Parity length (bytes)
    value: '127'
  states: {}
- name: parity_pub_addr
  id: variable
  parameters:
    comment: ZeroMQ address for parity PUB
    value: '"tcp://127.0.0.1:9200"'
  states: {}
- name: peer_ctrl_addr
  id: variable
  parameters:
    comment: ZeroMQ address for control in
    value: '"tcp://127.0.0.1:9002"'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    comment: Sample rate for SDR
    value: '2000000'
  states: {}
- name: sdr_uri
  id: variable
  parameters:
    comment: PlutoSDR URI
    value: '"ip:192.168.2.1"'
  states: {}
- name: vector_size
  id: variable
  parameters:
    comment: Number of IQ samples to collect
    value: '8192'
  states: {}
- name: PHYSEC_feature_extraction_block_0
  id: PHYSEC_feature_extraction_block
  parameters:
    model_path: /workspace/siwn/gr-PHYSEC/examples/QExtractor.onnx
  states: {}
- name: PHYSEC_feature_quantization_block_0
  id: PHYSEC_feature_quantization_block
  parameters:
    quantization_method: mean_threshold
  states: {}
- name: PHYSEC_parity_generation_block_0
  id: PHYSEC_parity_generation_block
  parameters:
    k: '128'
    key_length: '512'
    n: '255'
  states: {}
- name: PHYSEC_privacy_amplification_block_0
  id: PHYSEC_privacy_amplification_block
  parameters:
    hash_algorithm: sha3_512
  states: {}
- name: PHYSEC_spectrogram_block_0
  id: PHYSEC_spectrogram_block
  parameters:
    fft_window: '512'
    vector_size: '8192'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Probe signal source
    freq: '1000000'
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_file_sink_key_0
  id: blocks_file_sink
  parameters:
    comment: Store final key (Alice)
    file: /tmp/alice_key.bin
    type: byte
    vlen: '128'
  states: {}
- name: blocks_file_sink_vec
  id: blocks_file_sink
  parameters:
    comment: Dump collected vectors (placeholder)
    type: complex
    vlen: '8192'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_parity
  id: blocks_message_debug
  parameters:
    comment: Parity PDU debug
  states: {}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    comment: Mute/unmute TX based on control
    mute: 'True'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    comment: Convert stream to vector for processing
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: Flow control for headless run
    samples_per_second: sample_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '127'
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt

      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self, name='Alice Controller', in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('tx_mute'))
              self.message_port_register_out(pmt.intern('out'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_ctrl)

          def handle_ctrl(self, msg):
              try:
                  val = pmt.symbol_to_string(msg) if pmt.is_symbol(msg) else str(pmt.to_python(msg))
              except Exception:
                  val = 'unknown'
              if 'start_tx' in val:
                  self.message_port_pub(pmt.intern('tx_mute'), pmt.to_pmt(False))
                  self.message_port_pub(pmt.intern('out'), pmt.intern('alice_start_tx'))
              elif 'stop_tx' in val:
                  self.message_port_pub(pmt.intern('tx_mute'), pmt.to_pmt(True))
                  self.message_port_pub(pmt.intern('out'), pmt.intern('alice_stop_tx'))
              elif 'collect' in val:
                  self.message_port_pub(pmt.intern('out'), pmt.intern('alice_collecting'))
              elif 'quantized' in val:
                  self.message_port_pub(pmt.intern('out'), pmt.intern('alice_quantized'))
              elif 'parity_sent' in val:
                  self.message_port_pub(pmt.intern('out'), pmt.intern('alice_parity_sent'))
              elif 'privacy_done' in val:
                  self.message_port_pub(pmt.intern('out'), pmt.intern('alice_privacy_done'))
              else:
                  self.message_port_pub(pmt.intern('out'), pmt.intern('alice_unknown'))
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    comment: PlutoSDR sink for transmitting probe
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2442000000'
    len_tag_key: packet_len
    samplerate: sample_rate
    type: fc32
    uri: sdr_uri
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    comment: PlutoSDR source for receiving IQ samples
    filter_source: '''Auto'''
    frequency: '2442000000'
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: sample_rate
    type: fc32
    uri: sdr_uri
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: monitor_addr
    bind: 'False'
    comment: Publish status updates to monitor
    timeout: '100'
  states: {}
- name: zeromq_pub_msg_sink_parity
  id: zeromq_pub_msg_sink
  parameters:
    address: parity_pub_addr
    bind: 'False'
    comment: Publish parity messages to peer
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: peer_ctrl_addr
    comment: Receive control messages from peer/controller
    timeout: '100'
  states: {}

connections:
- [PHYSEC_feature_extraction_block_0, '0', PHYSEC_feature_quantization_block_0, '0']
- [PHYSEC_feature_quantization_block_0, '0', PHYSEC_parity_generation_block_0, '0']
- [PHYSEC_parity_generation_block_0, '0', blocks_vector_to_stream_0, '0']
- [PHYSEC_parity_generation_block_0, '1', PHYSEC_privacy_amplification_block_0, '0']
- [PHYSEC_privacy_amplification_block_0, '0', blocks_file_sink_key_0, '0']
- [PHYSEC_spectrogram_block_0, '0', PHYSEC_feature_extraction_block_0, '0']
- [analog_sig_source_x_0, '0', blocks_mute_xx_0, '0']
- [blocks_mute_xx_0, '0', iio_pluto_sink_0, '0']
- [blocks_stream_to_vector_0, '0', PHYSEC_spectrogram_block_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_file_sink_vec, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_vector_to_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [epy_block_0, out, zeromq_pub_msg_sink_0, in]
- [epy_block_0, tx_mute, blocks_mute_xx_0, set_mute]
- [iio_pluto_source_0, '0', blocks_throttle_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_parity, print]
- [pdu_tagged_stream_to_pdu_0, pdus, zeromq_pub_msg_sink_parity, in]
- [zeromq_sub_msg_source_0, out, epy_block_0, msg_in]

metadata:
  file_format: 1
