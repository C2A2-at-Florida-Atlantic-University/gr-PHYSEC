options:
  parameters:
    author: Alice Node
    category: '[PHYSEC]'
    comment: Alice protocol node with messaging triggers (ZeroMQ) and PlutoSDR
    description: Alice full-node skeleton in YAML GRC format (GR 3.10)
    generate_options: no_gui
    id: alice_node_protocol
    output_language: python
    run: 'False'
    title: Alice Protocol Node - PHYSEC
  states: {}

blocks:
- name: key_len
  id: variable
  parameters:
    comment: Final key length (bytes)
    value: '128'
  states: {}
- name: monitor_addr
  id: variable
  parameters:
    comment: ZeroMQ address for status out
    value: '"tcp://127.0.0.1:9100"'
  states: {}
- name: parity_len
  id: variable
  parameters:
    comment: Parity length (bytes)
    value: '127'
  states: {}
- name: parity_pub_addr
  id: variable
  parameters:
    comment: ZeroMQ address for parity PUB
    value: '"tcp://127.0.0.1:9200"'
  states: {}
- name: peer_ctrl_addr
  id: variable
  parameters:
    comment: ZeroMQ address for control in
    value: '"tcp://127.0.0.1:9102"'
  states: {}
- name: peer_ctrl_pub_addr
  id: variable
  parameters:
    comment: ZeroMQ address for control out (to peer)
    value: '"tcp://127.0.0.1:9101"'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    comment: Sample rate for SDR
    value: '2000000'
  states: {}
- name: sdr_uri
  id: variable
  parameters:
    comment: PlutoSDR URI
    value: '"ip:192.168.65.254"'
  states: {}
- name: vector_size
  id: variable
  parameters:
    comment: Number of IQ samples to collect
    value: '8192'
  states: {}
- name: PHYSEC_feature_extraction_block_0
  id: PHYSEC_feature_extraction_block
  parameters:
    model_path: /workspace/siwn/gr-PHYSEC/examples/QExtractor.onnx
  states: {}
- name: PHYSEC_feature_quantization_block_0
  id: PHYSEC_feature_quantization_block
  parameters:
    quantization_method: mean_threshold
  states: {}
- name: PHYSEC_parity_generation_block_0
  id: PHYSEC_parity_generation_block
  parameters:
    k: '128'
    key_length: '512'
    n: '255'
  states: {}
- name: PHYSEC_privacy_amplification_block_0
  id: PHYSEC_privacy_amplification_block
  parameters:
    hash_algorithm: sha3_512
  states: {}
- name: PHYSEC_spectrogram_block_0
  id: PHYSEC_spectrogram_block
  parameters:
    fft_window: '512'
    vector_size: '8192'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Probe signal source
    freq: '1000000'
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Probe signal source
    freq: '1000000'
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_file_sink_key_0
  id: blocks_file_sink
  parameters:
    comment: Store final key (Alice)
    file: /tmp/alice_key.bin
    type: byte
    vlen: '128'
  states: {state: disabled}
- name: blocks_file_sink_vec
  id: blocks_file_sink
  parameters:
    comment: Dump collected vectors (placeholder)
    type: complex
    vlen: '8192'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_parity_0
  id: blocks_message_debug
  parameters:
    comment: Parity PDU debug
  states: {}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    comment: Mute/unmute TX based on control
    mute: 'True'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
    vlen: '128'
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: Add length tag for parity PDUs
    len_tag_key: '"packet_len"'
    packet_len: parity_len
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    comment: Convert stream to vector for processing
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '127'
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt

      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self, name='Alice Controller', in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('tx_mute'))
              self.message_port_register_out(pmt.intern('out'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_ctrl)

          def handle_ctrl(self, msg):
              try:
                  val = pmt.symbol_to_string(msg) if pmt.is_symbol(msg) else str(pmt.to_python(msg))
              except Exception:
                  val = 'unknown'
              if 'start_tx' in val:
                  self.message_port_pub(pmt.intern('tx_mute'), pmt.to_pmt(False))
                  self.message_port_pub(pmt.intern('out'), pmt.intern('alice_start_tx'))
              elif 'stop_tx' in val:
                  self.message_port_pub(pmt.intern('tx_mute'), pmt.to_pmt(True))
                  self.message_port_pub(pmt.intern('out'), pmt.intern('alice_stop_tx'))
              elif 'collect' in val:
                  self.message_port_pub(pmt.intern('out'), pmt.intern('alice_collecting'))
              elif 'quantized' in val:
                  self.message_port_pub(pmt.intern('out'), pmt.intern('alice_quantized'))
              elif 'parity_sent' in val:
                  self.message_port_pub(pmt.intern('out'), pmt.intern('alice_parity_sent'))
              elif 'privacy_done' in val:
                  self.message_port_pub(pmt.intern('out'), pmt.intern('alice_privacy_done'))
              else:
                  self.message_port_pub(pmt.intern('out'), pmt.intern('alice_unknown'))
  states: {state: disabled}
- name: epy_block_ctrl
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt

      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self, name='Alice Controller', in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_in(pmt.intern('evt_in'))
              self.message_port_register_out(pmt.intern('tx_mute'))
              self.message_port_register_out(pmt.intern('out'))
              self.message_port_register_out(pmt.intern('peer'))
              self.message_port_register_out(pmt.intern('rx_ctrl'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
              self.set_msg_handler(pmt.intern('evt_in'), self.handle_evt)
              self.message_port_pub(pmt.intern('tx_mute'), pmt.to_pmt(True))
              self.state = 'idle'
          def handle_msg(self, msg):
              val = pmt.symbol_to_string(msg) if pmt.is_symbol(msg) else str(pmt.to_python(msg))
              if val == 'probe_req' and self.state == 'idle':
                  self.message_port_pub(pmt.intern('out'), pmt.intern('alice_accept'))
                  self.message_port_pub(pmt.intern('rx_ctrl'), pmt.intern('start'))
                  self.state = 'collecting'
              elif val == 'bob_collect_done' and self.state == 'txing':
                  self.message_port_pub(pmt.intern('tx_mute'), pmt.to_pmt(True))
                  self.message_port_pub(pmt.intern('out'), pmt.intern('alice_tx_stop'))
                  self.state = 'processing'
              elif val in ('reconcile_ok','reconcile_fail'):
                  self.message_port_pub(pmt.intern('out'), pmt.intern('alice_'+val))
              else:
                  self.message_port_pub(pmt.intern('out'), pmt.intern('alice_evt_'+val))
          def handle_evt(self, msg):
              val = pmt.symbol_to_string(msg) if pmt.is_symbol(msg) else str(pmt.to_python(msg))
              if val == 'rx_collected' and self.state == 'collecting':
                  self.message_port_pub(pmt.intern('tx_mute'), pmt.to_pmt(False))
                  self.message_port_pub(pmt.intern('peer'), pmt.intern('alice_tx_start'))
                  self.message_port_pub(pmt.intern('out'), pmt.intern('alice_tx_start'))
                  self.state = 'txing'
    comment: Alice handshake controller
  states: {}
- name: epy_block_rx_gate
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np, pmt

      class blk(gr.sync_block):
          def __init__(self, num_items=8192):
              gr.sync_block.__init__(self, name='RX Gate', in_sig=[np.complex64], out_sig=[np.complex64])
              self.num_items = int(num_items); self.enabled = False; self.count = 0
              self.message_port_register_in(pmt.intern('ctrl'))
              self.message_port_register_out(pmt.intern('evt'))
              self.set_msg_handler(pmt.intern('ctrl'), self._on_ctrl)
          def _on_ctrl(self, msg):
              val = pmt.symbol_to_string(msg) if pmt.is_symbol(msg) else str(pmt.to_python(msg))
              if val == 'start': self.enabled = True; self.count = 0
          def work(self, ins, outs):
              if not self.enabled: return 0
              n = min(len(ins[0]), len(outs[0]), self.num_items - self.count)
              outs[0][:n] = ins[0][:n]; self.count += n
              if self.count >= self.num_items:
                  self.enabled = False
                  self.message_port_pub(pmt.intern('evt'), pmt.intern('rx_collected'))
              return n
    comment: Message-gated RX pass-through of N items
    num_items: vector_size
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    comment: PlutoSDR sink for transmitting probe
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2442000000'
    samplerate: sample_rate
    type: fc32
    uri: sdr_uri
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    comment: PlutoSDR source for receiving IQ samples
    filter_source: '''Auto'''
    frequency: '2442000000'
    gain1: '''slow_attack'''
    len_tag_key: ''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: sample_rate
    type: fc32
    uri: sdr_uri
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: monitor_addr
    bind: 'False'
    comment: Publish status updates to monitor
    timeout: '100'
  states: {}
- name: zeromq_pub_msg_sink_ctrl
  id: zeromq_pub_msg_sink
  parameters:
    address: peer_ctrl_pub_addr
    comment: Publish control messages to peer
    timeout: '100'
  states: {}
- name: zeromq_pub_msg_sink_parity
  id: zeromq_pub_msg_sink
  parameters:
    address: parity_pub_addr
    comment: Publish parity messages to peer
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: peer_ctrl_addr
    comment: Receive control messages from peer/controller
    timeout: '100'
  states: {}

connections:
- [PHYSEC_feature_extraction_block_0, '0', PHYSEC_feature_quantization_block_0, '0']
- [PHYSEC_feature_quantization_block_0, '0', PHYSEC_parity_generation_block_0, '0']
- [PHYSEC_parity_generation_block_0, '0', blocks_vector_to_stream_0, '0']
- [PHYSEC_parity_generation_block_0, '1', PHYSEC_privacy_amplification_block_0, '0']
- [PHYSEC_privacy_amplification_block_0, '0', blocks_file_sink_key_0, '0']
- [PHYSEC_privacy_amplification_block_0, '0', blocks_null_sink_0, '0']
- [PHYSEC_spectrogram_block_0, '0', PHYSEC_feature_extraction_block_0, '0']
- [analog_sig_source_x_0, '0', blocks_mute_xx_0, '0']
- [analog_sig_source_x_0_0, '0', epy_block_rx_gate, '0']
- [blocks_mute_xx_0, '0', blocks_null_sink_1, '0']
- [blocks_mute_xx_0, '0', iio_pluto_sink_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_stream_to_vector_0, '0', PHYSEC_spectrogram_block_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_file_sink_vec, '0']
- [blocks_vector_to_stream_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [epy_block_ctrl, out, blocks_message_debug_parity_0, print]
- [epy_block_ctrl, out, zeromq_pub_msg_sink_0, in]
- [epy_block_ctrl, peer, blocks_message_debug_parity_0, print]
- [epy_block_ctrl, peer, zeromq_pub_msg_sink_ctrl, in]
- [epy_block_ctrl, rx_ctrl, blocks_message_debug_parity_0, print]
- [epy_block_ctrl, rx_ctrl, epy_block_rx_gate, ctrl]
- [epy_block_ctrl, tx_mute, blocks_message_debug_parity_0, print]
- [epy_block_ctrl, tx_mute, blocks_mute_xx_0, set_mute]
- [epy_block_rx_gate, '0', blocks_stream_to_vector_0, '0']
- [epy_block_rx_gate, evt, blocks_message_debug_parity_0, print]
- [epy_block_rx_gate, evt, epy_block_ctrl, evt_in]
- [iio_pluto_source_0, '0', epy_block_rx_gate, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_parity_0, print]
- [pdu_tagged_stream_to_pdu_0, pdus, zeromq_pub_msg_sink_parity, in]
- [zeromq_sub_msg_source_0, out, blocks_message_debug_parity_0, print]
- [zeromq_sub_msg_source_0, out, epy_block_ctrl, msg_in]

metadata:
  file_format: 1
