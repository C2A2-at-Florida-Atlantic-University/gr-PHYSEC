options:
  parameters:
    author: Bob Node
    category: '[PHYSEC]'
    comment: Bob protocol node with messaging triggers (ZeroMQ) and PlutoSDR
    description: Bob full-node skeleton in YAML GRC format (GR 3.10)
    generate_options: no_gui
    id: bob_node_protocol
    output_language: python
    run: 'False'
    run_command: env PHYSEC_RX_DELAY_MS=300 {python} -u {filename}
    title: Bob Protocol Node - PHYSEC
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    comment: Number of IQ samples to collect
    value: '2400000000'
  states: {}
- name: monitor_addr
  id: variable
  parameters:
    comment: ZeroMQ address for status out
    value: '"tcp://192.168.0.142:9101"'
  states: {}
- name: monitor_addr
  id: variable
  parameters:
    comment: ZeroMQ address for status out
    value: '"tcp://127.0.0.1:9101"'
  states: {state: disabled}
- name: parity_len
  id: variable
  parameters:
    comment: Number of IQ samples to collect
    value: '127'
  states: {}
- name: parity_sub_addr
  id: variable
  parameters:
    comment: ZeroMQ address for parity SUB
    value: '"tcp://192.168.0.5:9200"'
  states: {}
- name: parity_sub_addr
  id: variable
  parameters:
    comment: ZeroMQ address for parity SUB
    value: '"tcp://127.0.0.1:9200"'
  states: {state: disabled}
- name: peer_ctrl_addr
  id: variable
  parameters:
    comment: ZeroMQ address for control in
    value: '"tcp://192.168.0.5:9101"'
  states: {}
- name: peer_ctrl_addr
  id: variable
  parameters:
    comment: ZeroMQ address for control in
    value: '"tcp://127.0.0.1:9101"'
  states: {state: disabled}
- name: peer_ctrl_pub_addr
  id: variable
  parameters:
    comment: ZeroMQ address for control out
    value: '"tcp://192.168.0.2:9102"'
  states: {}
- name: peer_ctrl_pub_addr
  id: variable
  parameters:
    comment: ZeroMQ address for control out
    value: '"tcp://127.0.0.1:9102"'
  states: {state: disabled}
- name: peer_trigger_addr
  id: variable
  parameters:
    comment: ZeroMQ address for parity SUB
    value: '"tcp://192.168.0.142:9103"'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    comment: Sample rate for SDR
    value: '1000000'
  states: {}
- name: sdr_uri
  id: variable
  parameters:
    comment: PlutoSDR URI
    value: '"ip:192.168.2.1"'
  states: {}
- name: vector_size
  id: variable
  parameters:
    comment: Number of IQ samples to collect
    value: '8192'
  states: {}
- name: PHYSEC_feature_extraction_block_0
  id: PHYSEC_feature_extraction_block
  parameters:
    model_path: /workspace/gr-PHYSEC/examples/QExtractor.onnx
  states: {}
- name: PHYSEC_feature_quantization_block_0
  id: PHYSEC_feature_quantization_block
  parameters:
    quantization_method: mean_threshold
  states: {}
- name: PHYSEC_privacy_amplification_block_0
  id: PHYSEC_privacy_amplification_block
  parameters:
    hash_algorithm: sha3_512
  states: {}
- name: PHYSEC_reconciliation_block_0
  id: PHYSEC_reconciliation_block
  parameters:
    k: '128'
    key_length: '512'
    n: '255'
  states: {}
- name: PHYSEC_spectrogram_block_0
  id: PHYSEC_spectrogram_block
  parameters:
    fft_window: '512'
    vector_size: '8192'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.01'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Probe signal source
    freq: '1000000'
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: bob_rx.iq
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: bob_tx.iq
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_key_0
  id: blocks_file_sink
  parameters:
    comment: Store final key (Bob)
    file: /tmp/bob_key.bin
    type: byte
    vlen: '128'
  states: {}
- name: blocks_file_sink_vec
  id: blocks_file_sink
  parameters:
    comment: Dump collected vectors (placeholder)
    file: bob.iq
    type: complex
    vlen: '8192'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    comment: Mute/unmute TX based on control
    mute: 'True'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    comment: Convert stream to vector for processing
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: parity_len
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt, os, threading, time

      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self, name='Bob Controller', in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_in(pmt.intern('evt_in'))
              self.message_port_register_out(pmt.intern('tx_mute'))
              self.message_port_register_out(pmt.intern('out'))
              self.message_port_register_out(pmt.intern('peer'))
              self.message_port_register_out(pmt.intern('rx_ctrl'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
              self.set_msg_handler(pmt.intern('evt_in'), self.handle_evt)
              self.message_port_pub(pmt.intern('tx_mute'), pmt.to_pmt(True))
              self.state = 'idle'
          def handle_msg(self, msg):
              val = pmt.symbol_to_string(msg) if pmt.is_symbol(msg) else str(pmt.to_python(msg))
              if val == 'start' and self.state == 'idle':
                  # Ask Alice to prepare RX for Bob's TX probe
                  self.message_port_pub(pmt.intern('peer'), pmt.intern('probe_req'))
                  # Optional delay to allow Alice RX to arm
                  try:
                      tx_start_delay_ms = float(os.getenv('PHYSEC_TX_START_DELAY_MS', '0'))
                  except Exception:
                      tx_start_delay_ms = 0.0
                  if tx_start_delay_ms > 0:
                      time.sleep(tx_start_delay_ms / 1000.0)
                  # Enable Bob TX and announce
                  self.message_port_pub(pmt.intern('tx_mute'), pmt.to_pmt(False))
                  self.message_port_pub(pmt.intern('out'), pmt.intern('bob_tx_start'))
                  self.state = 'txing'
              elif val == 'alice_tx_start' and self.state in ('txing','tx_done'):
                  # Mute Bob TX immediately, then start RX after optional delay
                  self.message_port_pub(pmt.intern('tx_mute'), pmt.to_pmt(True))
                  try:
                      rx_delay_ms = float(os.getenv('PHYSEC_RX_DELAY_MS', '10'))
                  except Exception:
                      rx_delay_ms = 10.0
                  if rx_delay_ms > 0:
                      time.sleep(rx_delay_ms / 1000.0)
                  self.message_port_pub(pmt.intern('rx_ctrl'), pmt.intern('start'))
                  self.message_port_pub(pmt.intern('out'), pmt.intern('bob_collecting'))
                  self.state = 'collecting'
              elif val == 'parity_recv':
                  self.message_port_pub(pmt.intern('out'), pmt.intern('bob_parity_recv'))
              elif val in ('reconcile_ok','reconcile_fail'):
                  self.message_port_pub(pmt.intern('out'), pmt.intern('bob_'+val))
                  self.message_port_pub(pmt.intern('peer'), pmt.intern(val))
                  self.state = 'idle'
              else:
                  self.message_port_pub(pmt.intern('out'), pmt.intern('bob_evt_'+val))
          def handle_evt(self, msg):
              val = pmt.symbol_to_string(msg) if pmt.is_symbol(msg) else str(pmt.to_python(msg))
              if val == 'rx_collected' and self.state == 'collecting':
                  self.message_port_pub(pmt.intern('tx_mute'), pmt.to_pmt(True))
                  self.message_port_pub(pmt.intern('peer'), pmt.intern('bob_collect_done'))
                  self.message_port_pub(pmt.intern('out'), pmt.intern('bob_collect_done'))
                  self.state = 'processing'
    comment: Bob handshake controller
  states: {}
- name: epy_block_push_iq
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np, socket, json, time, threading, os

      class blk(gr.sync_block):
          def __init__(self, vlen=8192, node_name="Bob"):
              gr.sync_block.__init__(self, name='Monitor Push IQ', in_sig=[(np.complex64, int(vlen))], out_sig=None)
              self.vlen = int(vlen)
              self.node_name = node_name
              self.host = os.getenv('MONITOR_HOST', '192.168.0.142')
              self.port = int(os.getenv('MONITOR_PORT', '9999'))
              self.sock = None
              self._lock = threading.Lock()
              self._connect()

          def _connect(self):
              try:
                  s = socket.socket(socket.AF_INET, socket.SOCK_STREAM)
                  s.settimeout(2.0)
                  s.connect((self.host, self.port))
                  s.settimeout(None)
                  self.sock = s
              except Exception:
                  self.sock = None

          def _send(self, payload):
              try:
                  if self.sock is None:
                      self._connect()
                  if self.sock:
                      data = (json.dumps(payload) + "\n").encode('utf-8')
                      with self._lock:
                          self.sock.sendall(data)
              except Exception:
                  self.sock = None

          def work(self, input_items, output_items):
              vecs = input_items[0]
              for v in vecs:
                  try:
                      data_str = repr([complex(x) for x in v.tolist()])
                      payload = {"type": "data_push", "data_type": "iq_samples", "node_name": self.node_name, "data": data_str, "timestamp": time.time()}
                      self._send(payload)
                  except Exception:
                      pass
              return len(vecs)
    comment: Push IQ vectors to monitor
    node_name: '"Bob"'
    vlen: vector_size
  states: {}
- name: epy_block_push_msg
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt, socket, json, time, threading, os

      class blk(gr.basic_block):
          def __init__(self, node_name="Bob", count_run_on="bob_tx_start"):
              gr.basic_block.__init__(self, name='Monitor Push (msg)', in_sig=None, out_sig=None)
              self.node_name = node_name
              self.count_run_on = str(count_run_on) if count_run_on else ""
              self.host = os.getenv('MONITOR_HOST', '192.168.0.142')
              self.port = int(os.getenv('MONITOR_PORT', '9999'))
              self.run_number = 0
              self.sock = None
              self._lock = threading.Lock()
              self._connect()
              self.message_port_register_in(pmt.intern('in'))
              self.set_msg_handler(pmt.intern('in'), self.handle_msg)

          def _connect(self):
              try:
                  s = socket.socket(socket.AF_INET, socket.SOCK_STREAM)
                  s.settimeout(2.0)
                  s.connect((self.host, self.port))
                  s.settimeout(None)
                  self.sock = s
              except Exception:
                  self.sock = None

          def _send(self, payload):
              try:
                  if self.sock is None:
                      self._connect()
                  if self.sock:
                      data = (json.dumps(payload) + "\n").encode('utf-8')
                      with self._lock:
                          self.sock.sendall(data)
              except Exception:
                  self.sock = None

          def handle_msg(self, msg):
              val = pmt.symbol_to_string(msg) if pmt.is_symbol(msg) else str(pmt.to_python(msg))
              if self.count_run_on and val == self.count_run_on:
                  self.run_number += 1
                  self._send({"type": "data_push", "data_type": "run_update", "node_name": self.node_name, "data": {"run_number": self.run_number, "action": "start"}, "timestamp": time.time()})
              self._send({"type": "data_push", "data_type": "protocol_step", "node_name": self.node_name, "data": {"step": val}, "timestamp": time.time()})
    comment: Push protocol steps and run updates to monitor
    count_run_on: '"bob_tx_start"'
    node_name: '"Bob"'
  states: {}
- name: epy_block_push_quant
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np, socket, json, time, threading, os

      class blk(gr.sync_block):
          def __init__(self, vlen=512, node_name="Bob"):
              gr.sync_block.__init__(self, name='Monitor Push Quantized', in_sig=[(np.uint8, int(vlen))], out_sig=None)
              self.vlen = int(vlen)
              self.node_name = node_name
              self.host = os.getenv('MONITOR_HOST', '192.168.0.142')
              self.port = int(os.getenv('MONITOR_PORT', '9999'))
              self.sock = None
              self._lock = threading.Lock()
              self._connect()

          def _connect(self):
              try:
                  s = socket.socket(socket.AF_INET, socket.SOCK_STREAM)
                  s.settimeout(2.0)
                  s.connect((self.host, self.port))
                  s.settimeout(None)
                  self.sock = s
              except Exception:
                  self.sock = None

          def _send(self, payload):
              try:
                  if self.sock is None:
                      self._connect()
                  if self.sock:
                      data = (json.dumps(payload) + "\n").encode('utf-8')
                      with self._lock:
                          self.sock.sendall(data)
              except Exception:
                  self.sock = None

          def work(self, input_items, output_items):
              vecs = input_items[0]
              for v in vecs:
                  try:
                      data_list = [int(x) for x in (v.tolist() if hasattr(v, 'tolist') else list(v))]
                      payload = {"type": "data_push", "data_type": "quantized_bits", "node_name": self.node_name, "data": data_list, "timestamp": time.time()}
                      self._send(payload)
                  except Exception:
                      pass
              return len(vecs)
    comment: Push quantized bit vectors to monitor
    node_name: '"Bob"'
    vlen: '512'
  states: {}
- name: epy_block_push_spec
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np, socket, json, time, threading, os

      class blk(gr.sync_block):
          def __init__(self, node_name="Bob"):
              gr.sync_block.__init__(self, name='Monitor Push Spectrogram', in_sig=[(np.float32, (6324))], out_sig=None)
              self.node_name = node_name
              self.host = os.getenv('MONITOR_HOST', '192.168.0.142')
              self.port = int(os.getenv('MONITOR_PORT', '9999'))
              self.sock = None
              self._lock = threading.Lock()
              self._connect()

          def _connect(self):
              try:
                  s = socket.socket(socket.AF_INET, socket.SOCK_STREAM)
                  s.settimeout(2.0)
                  s.connect((self.host, self.port))
                  s.settimeout(None)
                  self.sock = s
              except Exception:
                  self.sock = None

          def _send(self, payload):
              try:
                  if self.sock is None:
                      self._connect()
                  if self.sock:
                      data = (json.dumps(payload) + "\n").encode('utf-8')
                      with self._lock:
                          self.sock.sendall(data)
              except Exception:
                  self.sock = None

          def work(self, input_items, output_items):
              specs = input_items[0]
              for spec in specs:
                  try:
                      data_list = spec.tolist() if hasattr(spec, 'tolist') else [list(row) for row in spec]
                      payload = {"type": "data_push", "data_type": "spectrogram", "node_name": self.node_name, "data": data_list, "timestamp": time.time()}
                      self._send(payload)
                  except Exception:
                      pass
              return len(specs)
    comment: Push spectrograms to monitor
    node_name: '"Bob"'
  states: {}
- name: epy_block_reconcile_monitor
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt
      import numpy as np

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self, name='Reconcile Monitor', in_sig=[(np.uint8,1)], out_sig=None)
              self.message_port_register_out(pmt.intern('out'))
          def work(self, input_items, output_items):
              flags = input_items[0]
              for f in flags:
                  val = int(f[0]) if hasattr(f, '__len__') else int(f)
                  msg = pmt.intern('reconcile_ok') if val != 0 else pmt.intern('reconcile_fail')
                  self.message_port_pub(pmt.intern('out'), msg)
              return len(flags)
    comment: Emit reconcile_ok/fail based on success flag stream
  states: {}
- name: epy_block_rx_gate
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np, pmt

      class blk(gr.sync_block):
          def __init__(self, num_items=8192):
              gr.sync_block.__init__(self, name='RX Gate', in_sig=[np.complex64], out_sig=[np.complex64])
              self.num_items = int(num_items); self.enabled = False; self.count = 0
              self.message_port_register_in(pmt.intern('ctrl'))
              self.message_port_register_out(pmt.intern('evt'))
              self.set_msg_handler(pmt.intern('ctrl'), self._on_ctrl)
          def _on_ctrl(self, msg):
              val = pmt.symbol_to_string(msg) if pmt.is_symbol(msg) else str(pmt.to_python(msg))
              if val == 'start': self.enabled = True; self.count = 0
          def work(self, ins, outs):
              if not self.enabled: return 0
              n = min(len(ins[0]), len(outs[0]), self.num_items - self.count)
              outs[0][:n] = ins[0][:n]; self.count += n
              if self.count >= self.num_items:
                  self.enabled = False
                  self.message_port_pub(pmt.intern('evt'), pmt.intern('rx_collected'))
              return n
    comment: Message-gated RX pass-through of N items
    num_items: vector_size
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    comment: PlutoSDR sink for transmitting probe
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: freq
    samplerate: sample_rate
    type: fc32
    uri: sdr_uri
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    comment: PlutoSDR source for receiving IQ samples
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''manual'''
    len_tag_key: ''
    manual_gain1: '70'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: sample_rate
    type: fc32
    uri: sdr_uri
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '3000'
    send_eof: 'False'
    type: complex
  states: {state: disabled}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '2000'
    src_zeros: 'False'
    type: complex
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: monitor_addr
    bind: 'False'
    comment: Publish status updates to monitor
    timeout: '100'
  states: {}
- name: zeromq_pub_msg_sink_ctrl
  id: zeromq_pub_msg_sink
  parameters:
    address: peer_ctrl_pub_addr
    comment: Publish control messages to peer (Alice)
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: peer_ctrl_addr
    comment: Receive control messages from peer/controller
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_parity
  id: zeromq_sub_msg_source
  parameters:
    address: parity_sub_addr
    comment: Receive parity messages from peer
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_trigger
  id: zeromq_sub_msg_source
  parameters:
    address: peer_trigger_addr
    comment: Receive trigger messages from peer
    timeout: '100'
  states: {}

connections:
- [PHYSEC_feature_extraction_block_0, '0', PHYSEC_feature_quantization_block_0, '0']
- [PHYSEC_feature_quantization_block_0, '0', PHYSEC_reconciliation_block_0, '0']
- [PHYSEC_feature_quantization_block_0, '0', epy_block_push_quant, '0']
- [PHYSEC_privacy_amplification_block_0, '0', blocks_file_sink_key_0, '0']
- [PHYSEC_reconciliation_block_0, '0', PHYSEC_privacy_amplification_block_0, '0']
- [PHYSEC_reconciliation_block_0, '1', epy_block_reconcile_monitor, '0']
- [PHYSEC_spectrogram_block_0, '0', PHYSEC_feature_extraction_block_0, '0']
- [PHYSEC_spectrogram_block_0, '0', epy_block_push_spec, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_mute_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_file_sink_0_0, '0']
- [blocks_add_xx_0, '0', network_udp_sink_0, '0']
- [blocks_mute_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_mute_xx_0, '0', iio_pluto_sink_0, '0']
- [blocks_stream_to_vector_0, '0', PHYSEC_spectrogram_block_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_file_sink_vec, '0']
- [blocks_stream_to_vector_0, '0', epy_block_push_iq, '0']
- [blocks_stream_to_vector_1, '0', PHYSEC_reconciliation_block_0, '1']
- [epy_block_0, out, blocks_message_debug_0, print]
- [epy_block_0, out, epy_block_push_msg, in]
- [epy_block_0, out, zeromq_pub_msg_sink_0, in]
- [epy_block_0, peer, blocks_message_debug_0, print]
- [epy_block_0, peer, zeromq_pub_msg_sink_ctrl, in]
- [epy_block_0, rx_ctrl, blocks_message_debug_0, print]
- [epy_block_0, rx_ctrl, epy_block_rx_gate, ctrl]
- [epy_block_0, tx_mute, blocks_message_debug_0, print]
- [epy_block_0, tx_mute, blocks_mute_xx_0, set_mute]
- [epy_block_reconcile_monitor, out, blocks_message_debug_0, print]
- [epy_block_reconcile_monitor, out, epy_block_0, msg_in]
- [epy_block_reconcile_monitor, out, zeromq_pub_msg_sink_0, in]
- [epy_block_rx_gate, '0', blocks_stream_to_vector_0, '0']
- [epy_block_rx_gate, evt, blocks_message_debug_0, print]
- [epy_block_rx_gate, evt, epy_block_0, evt_in]
- [iio_pluto_source_0, '0', epy_block_rx_gate, '0']
- [network_udp_source_0, '0', blocks_file_sink_0, '0']
- [network_udp_source_0, '0', epy_block_rx_gate, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_stream_to_vector_1, '0']
- [zeromq_sub_msg_source_0, out, blocks_message_debug_0, print]
- [zeromq_sub_msg_source_0, out, epy_block_0, msg_in]
- [zeromq_sub_msg_source_parity, out, blocks_message_debug_0, print]
- [zeromq_sub_msg_source_parity, out, pdu_pdu_to_tagged_stream_0, pdus]
- [zeromq_sub_msg_source_trigger, out, blocks_message_debug_0, print]
- [zeromq_sub_msg_source_trigger, out, epy_block_0, msg_in]

metadata:
  file_format: 1
