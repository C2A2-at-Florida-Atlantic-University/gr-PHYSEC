options:
  parameters:
    author: gr-PHYSEC Example
    category: Examples
    comment: Example flowgraph for PHYSEC channel fingerprinting using FFT-based spectrograms
    description: Demonstrates channel fingerprinting using the PHYSEC block with FFT spectrogram generation
    generate_options: qt_gui
    hier_block_src_path: '.:src:'
    id: fingerprint_example
    output_language: python
    title: PHYSEC Fingerprint Example - FFT Spectrogram
  states: {}

blocks:
- name: centerFrequency
  id: variable
  parameters:
    comment: Center frequency for SDR (2.4 GHz)
    value: '2400000000'
  states: {}
- name: keyLength
  id: variable
  parameters:
    comment: Cryptographic key length in bits
    value: '128'
  states: {}
- name: sampleRate
  id: variable
  parameters:
    comment: Sample rate for SDR (50 MHz)
    value: '1000000'
  states: {}
- name: vectorSize
  id: variable
  parameters:
    comment: Vector size for FFT processing (4096 samples = 2^12)
    value: '8192'
  states: {}
- name: PHYSEC_fingerprint_block_0
  id: PHYSEC_fingerprint_block
  parameters:
    center_freq: centerFrequency
    comment: PHYSEC fingerprinting block using FFT spectrograms
    key_length: keyLength
    model_path: /workspace/gr-PHYSEC/models/QExtractor.onnx
    model_type: quadruplet
    sample_rate: sampleRate
    vector_size: vectorSize
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: Debug output for fingerprint messages
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters:
    comment: Debug output for generated keys
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    comment: Collects samples into vectors for FFT processing
    num_items: vectorSize
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: Throttle for testing (can be removed in production)
    samples_per_second: sampleRate
    type: complex
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    comment: ADALM-PLUTO SDR source for IQ samples
    filter_source: '''Auto'''
    frequency: centerFrequency
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: sampleRate
    type: fc32
    uri: '"ip:192.168.65.254"'
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', PHYSEC_fingerprint_block_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [iio_pluto_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
